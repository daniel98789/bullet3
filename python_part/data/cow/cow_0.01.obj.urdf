Commit message: Cow demo DONE

File: python_part/data/cow/cow_0.01.obj.urdf (robot description, URDF)
Before this commit: robot data, 1 links, 0 joints
Links:
- link _name: geometry collision mesh filename=cow_0.01.obj scale=1 1 1; visual mesh filename=cow_0.01.obj scale=1 1 1
